# Repository jpskenn/Aida

File README.md:

# Aida（アイーダ）

Yet another split keyboard, based on SandyLP.

Aida is a 40% split keyboard with symmetrical row staggered layout and key height optimization.

---

Aidaは左右対称ロースタッガード配列の40%分割型キーボードで、スイッチの配置を立体的にして高さ方向への最適化をおこなっています。

前機種の[SandyLP](https://github.com/jpskenn/SandyLP)を元に、分割型へ派生しました。

## 開発経緯

〓「キーボード遍歴の振り返り」というところから、分割型への期待、カラムスタガのつらさなども入れて説明し、現在Aidaに到達しているということを言いたい。

右手小指あたりが多少楽になるUS配列。Logicool 型番？

打鍵感のよい（しっかりとした筐体、静電容量スイッチ、絶妙なラバーカップの重さやフォースカーブなど） Realforce 英語、HHKB Pro2〓だったか？）、Realforce R2 All 35g

左右対称、分割型（肩、腕を開いたポジション） Ergo Dash
しかし、指の長さに合わせてキーをずらすカラムスタガは、自分の手（指）に合っておらず、また、小指に縦3キー以上は届くはずもなく、物理的に不可能だった。
それと、Modキーを親指に集中させるには、まだ自分の打鍵能力が成熟していない状態で、「小指キーにModを割り当てているが、そのキーに小指が届かない」というつらさが加わり、カラムスタガに失望し離脱することになった。
（肩、腕を開いたポジションをとれることはとてもよく、分割型には希望がいっぱい）

以前開発した[Sandy](https://github.com/jpskenn/Sandy)を1年半ほど使い続け、日常使いの長期ロードテストとして十分な情報を得ることができました。  
その情報を元にSandyのアップデート版（Sandy DN0040）の開発をおこない、あとは基板製造の発注をするだけの段階となっていましたが、Sandyの課題のひとつとして挙げていた手首の負荷軽減、つまりキーボードを低くする変更を取り込まなかったことが様々な思いの中でほんのりと燻り続けていました。

ちょうどその頃、Choc V2スイッチのラインナップにたいへん素性の良い静音タイプが追加されました。そして、自分が普段好んで使っているMX用のキーキャップをそのスイッチと組み合わせて使えそうだという情報が得られたことから、ロープロファイルのスイッチを使用したSandyの派生版開発に踏み切りました。  

使用するスイッチの変更で、派生版の開発においてそこそこの量の設計変更が見込まれることから、ついでにキーレイアウトも変更することにしました。  
これまでに開発した`Jones`や`Sandy`では、頒布・販売することを念頭に想定するユーザーの最大公約数的なところへ歩み寄ったレイアウトにしていましたが、今回は自分の使用スタイルを最優先し、自分にとって不要な数字行や左右端のシフトキーなどを取り除いて、少し尖ったレイアウトに変更しました。

こうして、SandyLPが誕生することとなりました。

## KiCad design PCB/Aida_Mid_Outside/Aida_Mid_Outside.kicad_pcb

Parts:
H1: COL_0_from_Base; MountingHole_2.2mm_M2_Pad_minimal
H2: COL_0_to_Base; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
H3: GND; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
SW_LEFT1: SW_Push; Kailh_socket_ChocV2_for_Reverse
SW_RIGHT1: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
TP1: COL0_from; PinHeader_1x01_P2.00mm_Vertical
TP2: COL0_to; PinHeader_1x01_P2.00mm_Vertical
TP3: GND; PinHeader_1x01_P2.00mm_Vertical

Connections:
COL_0_from_Base: H1.1, SW_LEFT1.1, SW_RIGHT1.1, TP1.1
COL_0_to_Base: H2.1, SW_LEFT1.2, SW_RIGHT1.2, TP2.1
GND: H3.1, TP3.1

Board: 2 copper layers, 25.7 x 23.5 mm, 8 parts (1 on the bottom side), 3 nets.

## KiCad design PCB/Aida_Top/Aida_Top.kicad_pcb

Parts:
H1: GND from Mid; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
H2: COL_4_from_Mid; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
H3: COL_4_to_Base_via_Mid; MountingHole_2.2mm_M2_Pad_minimal
SW_LEFT1: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
SW_RIGHT1: SW_Push; Kailh_socket_ChocV2_for_Reverse
TP1: GND; PinHeader_1x01_P2.00mm_Vertical
TP2: COL4_from; PinHeader_1x01_P2.00mm_Vertical
TP3: COL4_to; PinHeader_1x01_P2.00mm_Vertical

Connections:
COL_4_from_Mid: H2.1, SW_LEFT1.1, SW_RIGHT1.1, TP2.1
COL_4_to_Base_via_Mid: H3.1, SW_LEFT1.2, SW_RIGHT1.2, TP3.1
GND: H1.1, TP1.1

Board: 2 copper layers, 31.0 x 23.5 mm, 8 parts (1 on the bottom side), 3 nets.

## KiCad design PCB/Aida_Mid_Inside/Aida_Mid_Inside.kicad_pcb

Parts:
H1: GND from Base/to Top; MountingHole_2.2mm_M2_Pad_minimal
H2: COL_3_from_Base; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
H3: COL_3_to_Base; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
H4: COL_4_from_Base/to_Top; MountingHole_2.2mm_M2_Pad_minimal
H5: COL_4_to_Base; MountingHole_M2_Through-hole_tap_THC-0.8-1.0-2_minimal
H6: COL_5_from_Base; MountingHole_2.2mm_M2_Pad_minimal
H7: COL_5_to_Base; MountingHole_2.2mm_M2_Pad_minimal
H8: COL_4_from_Top_to_Base; MountingHole_2.2mm_M2_Pad_minimal
SW_LEFT1, SW_LEFT2, SW_LEFT3: SW_Push; Kailh_socket_ChocV2_small_#2pad_for_Reverse_no_hole
SW_RIGHT1, SW_RIGHT2, SW_RIGHT3: SW_Push; Kailh_socket_ChocV2_for_Reverse
TP1: GND; PinHeader_1x01_P2.00mm_Vertical
TP2: COL3_from; PinHeader_1x01_P2.00mm_Vertical
TP3: COL3_to; PinHeader_1x01_P2.00mm_Vertical
TP4: COL4_from; PinHeader_1x01_P2.00mm_Vertical
TP5: COL4_to; PinHeader_1x01_P2.00mm_Vertical
TP6: COL5_from; PinHeader_1x01_P2.00mm_Vertical
TP7: COL5_to; PinHeader_1x01_P2.00mm_Vertical
TP8: COL4_from_Top; PinHeader_1x01_P2.00mm_Vertical

Connections:
COL_3_from_Base: H2.1, SW_LEFT1.1, SW_RIGHT1.1, TP2.1
COL_3_to_Base: H3.1, SW_LEFT1.2, SW_RIGHT1.2, TP3.1
COL_4_from_Base: H4.1, SW_LEFT2.1, SW_RIGHT2.1, TP4.1
COL_4_from_Top_to_Base: H8.1, TP8.1
COL_4_to_Base: H5.1, SW_LEFT2.2, SW_RIGHT2.2, TP5.1
COL_5_from_Base: H6.1, SW_LEFT3.1, SW_RIGHT3.1, TP6.1
COL_5_to_Base: H7.1, SW_LEFT3.2, SW_RIGHT3.2, TP7.1
GND: H1.1, TP1.1

Notes on the sheet:
Topのスイッチ出力は、 Midとは別にBaseへ伝達する。

Board: 2 copper layers, 50.3 x 61.6 mm, 22 parts (3 on the bottom side), 8 nets.

## Commit log

2026-02-05 test
2026-02-06 書き始め
2026-02-08 回路作成中
2026-02-11 左手の回路が完成
2026-02-11 PCBの部品配置をやり始めた。左右の部品を仕分けした。
2026-02-11 左手パーツ配置中。右手マトリクス修正
2026-02-13 左手パーツ配置中。ネジ位置で悩み中。
2026-02-14 左手パーツ配置中。ネジ位置ほぼ確定。MCUまわり配置中。
2026-02-15 基板4枚、位置決め完了。
2026-02-16 プレート作成中
2026-02-17 プレート類調整中。LED位置検討中。
2026-02-17 LED位置、とりあえず決定。
2026-02-17 右手パーツ配置中
2026-02-17 マトリクス行列のテストポイント追加
2026-02-17 左手側配線中
2026-02-19 左手側配線。ほぼ完了。
2026-02-21 ボトムプレートの穴あけ用に、左手側パーツ配置調整。
2026-02-21 ボトムプレート作成中。基板Baseのパーツ位置調整中。
2026-02-21 ボトムプレート、一旦完成。
2026-02-22 テストポイントを追加、配置した。
2026-02-22 右手パーツ配置中。MCUまわりきびしい
2026-02-23 配線すべて繋いだ
2026-02-23 基板Baseのパーツ位置変更に合わせて、プレートの穴を再調整。
2026-02-23 ソケットの3Dモデルを、1.2ｍｍ厚のPCBに合わせて位置調整。
2026-02-23 ResetとBootスイッチのシルクを追加
2026-02-23 3Dモデルの設定
2026-02-23 USBコネクタ付近の外形変更
2026-02-23 ボトムプレートの下にカバーを追加
2026-02-23 不要データ削除
2026-02-23 LEDのフットプリント変更。配線調整中。
2026-02-24 配線調整
2026-02-24 USB配線長を調整した
2026-02-24 原点ガイドを追加。基板Mid_InsideのLED穴形状調整
2026-02-25 開発ナンバーと表裏を記載
2026-02-25 add TRRS
2026-02-26 組み立てを更新中
2026-02-26 目次更新
2026-02-27 全体的に更新
2026-02-28 スルーホールタップの型番変更に伴い、ランド、3Dモデルも変更。
2026-02-28 BOM記入
2026-02-28 LEDを1/16u下へ移動。 右手のフラッシュメモリとの干渉回避のためボトムプレートの穴位置調整。
2026-03-01 製造用出力
2026-03-01 Top関連の組み付け方法変更。パーツ数量確定。
2026-03-02 手順更新。
2026-03-02 フラッシュメモリのLCSC番号間違い修正
2026-03-03 細部修正
2026-03-06 メモ追加
2026-03-09 VIA用JSONファイル追加
2026-03-12 基板セットアップを更新
2026-03-14 キー配置修正
2026-03-16 プロト版の組み立て経験をフィードバック中
2026-03-16 コメント追加
2026-03-17 QMKで右手用ピン指定をやめたのに合わせる
2026-03-18 開発経緯を書きかけ
2026-03-18 不要設定削除。Web版VIAで認識。
    なお、マトリクスのテストは反応なし。
2026-03-21 フォーマット
2026-03-29 DN0020向けに回路図を更新
2026-03-29 フットプリント割り当て修正
2026-03-29 とりあえずキーを配置した
2026-04-05 Hapticドライバまわりを修正
2026-04-05 VBUS検知の抵抗値を指定 #49
2026-04-05 左右判定ピンに左右別々の要素を割り当てた #52
2026-04-05 VBUSをリザーブピンへ出した #50
